Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2019-04-23T13:17:48
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20181011_1500(x64) - Exporter 18.3.2.7 - Alternate UI 18.3.2.7
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Apr 23 13:17:48 2019 * Host: Fanie * Database: C:\Users\Fanie\AppData\Local\Temp\{06827673-D6FD-42D8-911D-5E15842F326C}\ifc * Database version: 5507 * Database creation date: Tue Apr 23 13:17:47 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Apr 23 13:17:48 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Apr 23 13:17:48 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: Bond-lok FD2-Kerb Drip Flashing, Bond-Lok FD2-Kerb Drip Flashing Family:Bond-lok FD2-Kerb Drip Flashing:201826
In: Level 1
Type - Material: ISQ 300, Galvanized Z275
Pset_BuildingElementProxyCommon - Reference: Bond-lok FD2-Kerb Drip Flashing
Pset_ManufacturerTypeInformation - Manufacturer: Global Roofing Solutions
